# Keil uVision project atk_f407.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\Drivers\SYSTEM\as5600;..\..\Drivers\SYSTEM\timer;..\..\Drivers\SYSTEM\led;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\SYSTEM\motor;..\..\Drivers\SYSTEM\spi;..\..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\..\Drivers\SYSTEM\adc;..\..\Drivers\SYSTEM\dma;..\..\Drivers\SYSTEM\lcd;..\..\Drivers\SYSTEM\i2c
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/AS5600/: as5600.c
    ../../Drivers/SYSTEM/TIMER/: atim.c gtim.c
    ../../Drivers/SYSTEM/adc/: adc.c
    ../../Drivers/SYSTEM/led/: led.c
    ../../Drivers/SYSTEM/spi/: spi.c
    ../../Drivers/SYSTEM/i2c/: i2c.c
  group Drivers/motor
    ../../Drivers/SYSTEM/motor/: Axis_transform.c IQ_math.c PI_Cale.c Svpwm_dq.c motor.c
  group Drive/lcd
    ../../Drivers/SYSTEM/lcd/: GUI.c lcd_drive.c QDTFT_demo.c
  group Readme
    ../../: readme.txt
